options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    realtime_scheduling: '1'
    thread_safe_setters: '1'
    title: Not titled yet
  states: {}

blocks:
- name: add_const
  id: variable_qtgui_range
  parameters:
    label: Shift Vert
    min_len: '50'
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1.95'
  states: {}
- name: fm_sensitivity
  id: variable_qtgui_range
  parameters:
    label: Sensitivity (FM)
    min_len: '100'
    start: '0.100'
    step: '0.05'
    stop: '0.500'
    value: '0.350'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    label0: CH3
    label1: CH4
    num_opts: '2'
    option0: 61.25e6
    option1: 67.25e6
    orient: Qt.QHBoxLayout
    type: real
    value: 67.25e6
    widget: radio_buttons
  states: {}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    label: Frequenz Shift (FM)
    min_len: '50'
    start: 1e6
    step: 0.1e6
    stop: 10e6
    value: 8.1e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Source Gain
    min_len: '10'
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: multiply_const
  id: variable_qtgui_range
  parameters:
    label: Sqeeze
    min_len: '10'
    start: '-20'
    step: '0.01'
    stop: '20'
    value: '-7.36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tau
  id: variable_qtgui_range
  parameters:
    label: Tau (FM Pre)
    min_len: '50'
    start: '1e-8'
    step: '0.1e-8'
    stop: '50e-8'
    value: '15e-8'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: '15e-8'
    fh: '-1'
    samp_rate: samp_rate
    tau: tau
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: .15 with 8.1-8.2 shift funktioniert
    sensitivity: fm_sensitivity
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: fm_sensitivity
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-0.4'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: add_const
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: .s16 extension
    file: /home/andreas/Projekte/gnuradio/create_ld_rf/output.s16
    type: short
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 2.5e6
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: freq_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.85'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: CVBS Invert
    const: multiply_const
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '128'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '910'
  states: {state: disabled}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (858, 25)
    type: float
    vlen: '910'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '910'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '910'
    type: float
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 4.6e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100e3, 30e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 2.5e6, 1e6)
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=1
    bb_gain0: '20'
    freq0: 14e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 10e6
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '16'
    freq0: freq
    gain0: gain
    gain_mode0: 'True'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    freqhalf: 'False'
    name: Baseband
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: CVBS
    label2: White
    label3: Burst
    label4: Blank
    name: CVBS Invert
    nconnections: '4'
    size: '1400'
    srate: samp_rate
    type: float
    ymax: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    int_max: '30'
    int_min: '-120'
    name: LD RF
    type: float
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '525'
    fps: '29'
    height: '480'
    type: short
    width: '525'
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: LD-RF-OhneSound
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: LD-RF-OhneSound
  states: {}

connections:
- [analog_fm_preemph_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_freqshift_cc_0_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_freqshift_cc_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_short_0_0, '0']
- [analog_rail_ff_0_0, '0', qtgui_waterfall_sink_x_0_2, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_add_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_float_to_short_1, '0', video_sdl_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_add_xx_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_float_to_short_1, '0']
- [blocks_stream_demux_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_demux_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', analog_fm_preemph_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
