options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    thread_safe_setters: '1'
    title: Not titled yet
  states: {}

blocks:
- name: audio_mod_left
  id: variable
  parameters:
    value: 2.301e6
  states: {}
- name: audio_mod_right
  id: variable
  parameters:
    value: 2.812e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 0e6
    step: 1e4
    stop: 100e6
    value: 61.25e6
  states: {}
- name: line_length
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
      (currently only NTSC supported)
    value: '910'
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      525 NTSC
      625 PAL
    value: '525'
  states: {}
- name: ntsc_high
  id: variable
  parameters:
    value: 9.31e6
  states: {}
- name: ntsc_low
  id: variable
  parameters:
    value: 4.52e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: source_samp_rate
  id: variable
  parameters:
    value: '14318181'
  states: {}
- name: video_mod_carrier
  id: variable
  parameters:
    value: 8.45e6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: '15e-8'
    fh: '-1'
    samp_rate: samp_rate
    tau: '15e-8'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: .15 with 8.1-8.2 shift funktioniert
    sensitivity: '0.35'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.9'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: .s16 extension
    file: /home/andreas/Projekte/gnuradio/gnuradio-laserdisc/output.s16
    type: short
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: 8.1e6
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.85'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: CVBS Invert
    const: '-7.5'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '128'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '910'
  states: {state: disabled}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (858, 25)
    type: float
    vlen: '910'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '910'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '910'
    type: float
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '16'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    freqhalf: 'False'
    name: Baseband
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    name: CVBS Invert
    size: '1400'
    srate: samp_rate
    type: float
    ymax: '0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    int_max: '30'
    int_min: '-120'
    name: LD RF
    type: float
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '525'
    fps: '29'
    height: '480'
    type: short
    width: '525'
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: LD-RF-OhneSound
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: LD-RF-OhneSound
  states: {}

connections:
- [analog_fm_preemph_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_freqshift_cc_0_0, '0']
- [analog_rail_ff_0_0, '0', blocks_float_to_short_0_0, '0']
- [analog_rail_ff_0_0, '0', qtgui_waterfall_sink_x_0_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_float_to_short_1, '0', video_sdl_sink_0, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_rail_ff_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_float_to_short_1, '0']
- [blocks_stream_demux_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_demux_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', analog_fm_preemph_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
